IMAGE_INSTALL_append = " opkg python c-ares"

